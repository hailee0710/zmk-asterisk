#include "asterisk.dtsi"

&kscan0 {
    compatible = "zmk,kscan-gpio-matrix";
    wakeup-source;
};

&physical_layout0 {
        kscan = <&kscan0>;
};

&left_encoder {
    status = "okay";
};
